<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC254xF256</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\app\bim_ivec.s51</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\app\bim_main.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2540EB\hal_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_flash.h</name>
    </file>
  </group>
</project>


