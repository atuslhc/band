<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>CC2541DK-HEALTHCARE</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>CC2541DK-CONSUMER</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>cc2540SBL-HEALTHCARE</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>cc2540SBL-CONSUMER</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>2</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <group>
      <name>ANCS</name>
      <file>
        <name>$PROJ_DIR$\..\Source\timeapp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\timeapp_config.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\timeapp_discovery.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Source\timeapp_ind.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_SensorTag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorTag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorTag.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorTag_Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SensorTagUser.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\serial2service.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\serial2Service.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\SerialApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\serialapp.h</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\services\saddr\saddr.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>Config</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_board_cfg.h</name>
        </file>
      </group>
      <group>
        <name>Drivers</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_aes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_aes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_ccm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_crc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_crc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_lcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_startup.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_types.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_uart.c</name>
        </file>
      </group>
      <group>
        <name>Includes</name>
      </group>
    </group>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2540DB\bin\CC2540_BLE_peri.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_None.lib</name>
    </file>
  </group>
  <group>
    <name>NPI</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\npi\npi_np\npi.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\bcomdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_cbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_ClockBLE.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\mcu\cc2540\osal_snv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
  </group>
  <group>
    <name>PROFILES</name>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\accelerometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\accelerometerservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Batt\battservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Batt\battservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\DeviceConfig\DeviceConfigService.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\devinfoservice-st.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\devinfoservice-st.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gapgattserver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\gatt_uuid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gattservapp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\gyroservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\gyroservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\HeartRate\heartrateservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\ImmediateAlert\ImmediateAlert.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\ImmediateAlert\immediateAlert.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\irtempservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\irtempservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\NotificationSignal\NotificationSignalService.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad_target.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\OAD\oad_target.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\peripheral.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\RSC\runningservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\RSC\runningservice.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\st_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\st_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\SensorProfile\testAlertNotification.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Thermometer\thermometerservice.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Thermometer\thermometerservice.h</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <file>
      <name>$PROJ_DIR$\..\..\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\buildConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\Revision.txt</name>
  </file>
</project>


