# IAR project Backup (3) of SensorTag.ewp, settings and files
configuration CC2541DK-HEALTHCARE (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: MODEL_TYPE=1; VENDOR_TYPE=2; INT_HEAP_LEN=2500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; HAL_UART_TRANS=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SensorProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\HeartRate; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\Proximity; ..\..\Profiles\Thermometer; ..\..\Profiles\ImmediateAlert; ..\..\Profiles\DeviceConfig; ..\..\Profiles\RSC; ..\Source
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration CC2541DK-CONSUMER (8051)
  as the first configuration, except:
  ICC8051.CCDefines: MODEL_TYPE=2; VENDOR_TYPE=2; INT_HEAP_LEN=2500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; HAL_UART_TRANS=TRUE
configuration cc2540SBL-HEALTHCARE (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: MODEL_TYPE=1; VENDOR_TYPE=2; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; EXT_MAX_TX_POWER=3; RSSI_DIFF=0; HAL_DMA=TRUE; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=FALSE; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; HAL_UART_TRANS=TRUE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SensorProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\Oad; ..\..\Profiles\HeartRate; ..\..\Profiles\HIDDev; ..\..\Profiles\Batt; ..\..\Profiles\Proximity; ..\..\Profiles\Thermometer; ..\..\Profiles\ImmediateAlert; ..\..\Profiles\DeviceConfig; ..\..\Profiles\RSC; ..\Source
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_uvu.xcl
configuration cc2540SBL-CONSUMER (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: MODEL_TYPE=2; VENDOR_TYPE=2; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=2500; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LED=FALSE; HAL_I2C=FALSE; HAL_ADC=FALSE; HAL_LCD=TRUE; HAL_LED=FALSE; HAL_KEY=FALSE; HAL_UART=TRUE; HAL_UART_TRANS=TRUE
  ICC8051.CCIncludePath2: as above
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_uvu.xcl
  group (top)
    ../../../: Revision.txt
  group APP
    ../Source/: OSAL_SensorTag.c SensorTag.c SensorTag.h SensorTag_Main.c SensorTagUser.h serial2service.c serial2Service.h SerialApp.c serialapp.h
  group APP/ANCS
    ../Source/: timeapp.h timeapp_config.c timeapp_discovery.c timeapp_ind.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_aes.h hal_ccm.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_mcu.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h hal_uart.c
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c npi.h
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/SensorProfile/: accelerometerservice.c accelerometerservice.h gyroservice.c gyroservice.h irtempservice.c irtempservice.h st_util.c st_util.h testAlertNotification.c
    ../../Profiles/Batt/: battservice.c battservice.h
    ../../Profiles/DeviceConfig/: DeviceConfigService.c
    ../Source/: devinfoservice-st.c devinfoservice-st.h
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheral.c peripheral.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/HeartRate/: heartrateservice.c
    ../../Profiles/ImmediateAlert/: ImmediateAlert.c immediateAlert.h
    ../../Profiles/NotificationSignal/: NotificationSignalService.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../Profiles/RSC/: runningservice.c runningservice.h
    ../../Profiles/Thermometer/: thermometerservice.c thermometerservice.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
