<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>i4_H-debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>i4_H-release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>i4_C-debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>i4_C-release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>rockband1-debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>rockband1-release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>I4B-debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>I4B-release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\src\AFE44x0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\BLE-LEUART-DMA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\common_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\cortex-m_faults.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\data_gather.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\debug.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\Device_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\display_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\flash_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\GlobalData.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\menu\led_font.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\menu\led_font.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\mems_tracking.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\menu\Menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\notification.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\signal_proc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\sleep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\menu\subMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\sys_sharing_source.c</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\Device\EnergyMicro\EFM32WG\Source\IAR\startup_efm32wg.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\Device\EnergyMicro\EFM32WG\Source\system_efm32wg.c</name>
    </file>
  </group>
  <group>
    <name>docs</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Revision.txt</name>
    </file>
  </group>
  <group>
    <name>Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\AD7156.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\BMM150.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\caplesense.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\CapTouchDetect.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\clockApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\DelayUsingTimerInt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\dmactrl.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\drv2605.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\i2c_driver.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\L3GD20H.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\LPS22HB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\LPS35HW.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\M00930.C</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\m25pxx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\mcp9804.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\mems.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\drivers\Si14x.c</name>
    </file>
  </group>
  <group>
    <name>DSP</name>
    <file>
      <name>$PROJ_DIR$\..\src\iar_cortexM4lf_math.a</name>
    </file>
  </group>
  <group>
    <name>emlib</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_acmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_burtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_cmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_emu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_lesense.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_letimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_leuart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_msc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_prs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_rmu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_system.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_vcmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\mcu\arm\EFM32\emlib\src\em_wdog.c</name>
    </file>
  </group>
  <group>
    <name>emWin</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\gui\emwin\lib\emwin_IAR_CM4F.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\gui\emwin\portable\GUI_X.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\gui\emwin\portable\GUIConf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\gui\emwin\portable\LCDConf.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <group>
      <name>portable</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\portable\CMSIS\cmsis_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\portable\MemMang\heap_1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\portable\MemMang\heap_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\portable\LowPower\low_power_tick_management.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\portable\IAR\ARM_CM4F\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\portable\IAR\ARM_CM4F\portasm.s</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\FreeRTOSConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\os\FreeRTOS\timers.c</name>
    </file>
  </group>
</project>


