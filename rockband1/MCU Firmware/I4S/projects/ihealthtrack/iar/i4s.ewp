# IAR project i4s.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG395F256 EnergyMicro EFM32WG395F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\..\projects\ihealthtrack\src\memlcdDriver; ..\..\..\projects\ihealthtrack\src; ..\..\..\projects\ihealthtrack\src\GUI; ..\..\..\projects\ihealthtrack\src\menu; ..\..\..\projects\ihealthtrack\src\menu\res; ..\..\..\projects\common\drivers\emwin; ..\..\..\projects\common\drivers; ..\..\..\gui\emwin\inc; ..\..\..\gui\emwin\portable; ..\..\..\usb\EMUSB\inc; ..\..\..\os\FreeRTOS\portable\iar\ARM_CM4F; ..\..\..\os\FreeRTOS\portable\CMSIS; ..\..\..\os\FreeRTOS\include; ..\..\..\mcu\arm\EFM32\Device\EnergyMicro\EFM32WG\Include; ..\..\..\mcu\arm\EFM32\emlib\inc; ..\..\..\mcu\arm\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32WG395F256; __ASM__
  AARM.AUserIncludes: ..\..\..\projects\ihealthtrack\src\memlcdDriver; ..\..\..\projects\ihealthtrack\src; ..\..\..\projects\common\drivers\emwin; ..\..\..\projects\common\drivers; ..\..\..\gui\emwin\inc; ..\..\..\gui\emwin\portable; ..\..\..\usb\EMUSB\inc; ..\..\..\os\FreeRTOS\portable\iar\ARM_CM4F; ..\..\..\os\FreeRTOS\portable\CMSIS; ..\..\..\os\FreeRTOS\include; ..\..\..\mcu\arm\EFM32\Device\EnergyMicro\EFM32WG\Include; ..\..\..\mcu\arm\EFM32\emlib\inc; ..\..\..\mcu\arm\CMSIS\Include
  OBJCOPY.OOCOutputFile: i4.bin
  ILINK.IlinkOutputFile: i4.out
  ILINK.IlinkIcfFile: ihealthtrack.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: i4s.bin
  ILINK.IlinkIcfFile: support-boot.icf
  group App
    ../src/: AFE44x0.c BLE-LEUART-DMA.c common_vars.c common_vars.h cortex-m_faults.c crc.c data_gather.c debug.h Device_task.c display_task.c flash_task.c GlobalData.c interrupt.c main.c notification.c sleep.c sys_sharing_source.c
    ../src/menu/: led_font.c led_font.h Menu.c subMenu.c
  group CMSIS
    ../../../mcu/arm/EFM32/Device/EnergyMicro/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../mcu/arm/EFM32/Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group docs
    ../../../docs/: TODO.doc 指标数据采集与存储.doc
    ../../../: 版本备忘.txt
  group Drivers
    ../../common/drivers/: adc.c bsp.c caplesense.c CapTouchDetect.c clock.c clockApp.c DelayUsingTimerInt.c dmactrl.c drv2605.c i2c_driver.c M00930.C m25pxx.c mcp9804.c Si14x.c
    ../src/: mems.c
  group DSP
    ../src/: iar_cortexM4lf_math.a mems_tracking_H.o signal_proc.o
  group emlib
    ../../../mcu/arm/EFM32/emlib/src/: em_acmp.c em_adc.c em_burtc.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group emWin
    ../../../gui/emwin/lib/: emwin_IAR_CM4F.a
    ../../../gui/emwin/portable/: GUI_X.c GUIConf.c LCDConf.c
  group FreeRTOS
    ../../../os/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../src/: FreeRTOSConfig.h
  group FreeRTOS/portable
    ../../../os/FreeRTOS/portable/CMSIS/: cmsis_os.c
    ../../../os/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c
    ../../../os/FreeRTOS/portable/LowPower/: low_power_tick_management.c
    ../../../os/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
