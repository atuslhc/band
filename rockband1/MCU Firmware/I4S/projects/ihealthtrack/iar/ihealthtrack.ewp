# IAR project ihealthtrack.ewp, settings and files
configuration i4_H-debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG395F256 EnergyMicro EFM32WG395F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=1; BOARD_TYPE=0; HEALTHCARE_TYPE; VENDOR_TYPE=2; FALL_DETECT_SUPPORT; SOS_HIT_SUPPORT; BATTERY_LIFE_OPTIMIZATION2; BGXXX
  ICCARM.CCIncludePath2: ..\..\..\projects\ihealthtrack\src\memlcdDriver; ..\..\..\projects\ihealthtrack\src; ..\..\..\projects\ihealthtrack\src\GUI; ..\..\..\projects\ihealthtrack\src\menu; ..\..\..\projects\ihealthtrack\src\menu\res; ..\..\..\projects\common\drivers\emwin; ..\..\..\projects\common\drivers; ..\..\..\gui\emwin\inc; ..\..\..\gui\emwin\portable; ..\..\..\usb\EMUSB\inc; ..\..\..\os\FreeRTOS\portable\iar\ARM_CM4F; ..\..\..\os\FreeRTOS\portable\CMSIS; ..\..\..\os\FreeRTOS\include; ..\..\..\mcu\arm\EFM32\Device\EnergyMicro\EFM32WG\Include; ..\..\..\mcu\arm\EFM32\emlib\inc; ..\..\..\mcu\arm\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32WG395F256; __ASM__
  AARM.AUserIncludes: ..\..\..\projects\ihealthtrack\src\memlcdDriver; ..\..\..\projects\ihealthtrack\src; ..\..\..\projects\common\drivers\emwin; ..\..\..\projects\common\drivers; ..\..\..\gui\emwin\inc; ..\..\..\gui\emwin\portable; ..\..\..\usb\EMUSB\inc; ..\..\..\os\FreeRTOS\portable\iar\ARM_CM4F; ..\..\..\os\FreeRTOS\portable\CMSIS; ..\..\..\os\FreeRTOS\include; ..\..\..\mcu\arm\EFM32\Device\EnergyMicro\EFM32WG\Include; ..\..\..\mcu\arm\EFM32\emlib\inc; ..\..\..\mcu\arm\CMSIS\Include
  OBJCOPY.OOCOutputFile: rockband0_MCU_H.bin
  ILINK.IlinkOutputFile: rockband0_MCU_H.out
  ILINK.IlinkIcfFile: ihealthtrack.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration i4_H-release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=1; BOARD_TYPE=0; HEALTHCARE_TYPE; VENDOR_TYPE=2; FALL_DETECT_SUPPORT; SOS_HIT_SUPPORT; BATTERY_LIFE_OPTIMIZATION2
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: support-boot.icf
configuration i4_C-debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=2; BOARD_TYPE=0; CONSUMER_TYPE; VENDOR_TYPE=2; GESTURE_DISP_SUPPORT; PPG_WORK_MODE_SET; BGXXX
  OBJCOPY.OOCOutputFile: i4s.bin
  ILINK.IlinkOutputFile: i4s.out
configuration i4_C-release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=2; BOARD_TYPE=0; CONSUMER_TYPE; VENDOR_TYPE=2; GESTURE_DISP_SUPPORT; PPG_WORK_MODE_SET
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: i4s.bin
  ILINK.IlinkOutputFile: i4s.out
  ILINK.IlinkIcfFile: support-boot.icf
configuration rockband1-debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=1; BOARD_TYPE=2; HEALTHCARE_TYPE; VENDOR_TYPE=2; FALL_DETECT_SUPPORT; SOS_HIT_SUPPORT; BATTERY_LIFE_OPTIMIZATION2; BGXXX
  OBJCOPY.OOCOutputFile: rockband1_MCU_H.bin
  ILINK.IlinkOutputFile: i4s.out
configuration rockband1-release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=1; BOARD_TYPE=2; HEALTHCARE_TYPE; VENDOR_TYPE=2; FALL_DETECT_SUPPORT; SOS_HIT_SUPPORT; BATTERY_LIFE_OPTIMIZATION2
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rockband1_MCU_H.bin
  ILINK.IlinkOutputFile: i4s.out
  ILINK.IlinkIcfFile: support-boot.icf
configuration I4B-debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=1; BOARD_TYPE=1; HEALTHCARE_TYPE; VENDOR_TYPE=1; FALL_DETECT_SUPPORT; SOS_HIT_SUPPORT; BATTERY_LIFE_OPTIMIZATION2; BGXXX
configuration I4B-release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; ARM_MATH_CM4; MODEL_TYPE=1; BOARD_TYPE=1; HEALTHCARE_TYPE; VENDOR_TYPE=1; FALL_DETECT_SUPPORT; SOS_HIT_SUPPORT; BATTERY_LIFE_OPTIMIZATION2
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: support-boot.icf
  group App
    ../src/: AFE44x0.c BLE-LEUART-DMA.c common_vars.c common_vars.h cortex-m_faults.c crc.c data_gather.c debug.h Device_task.c display_task.c flash_task.c GlobalData.c interrupt.c main.c mems_tracking.c notification.c signal_proc.c sleep.c sys_sharing_source.c
    ../src/menu/: led_font.c led_font.h Menu.c subMenu.c
  group CMSIS
    ../../../mcu/arm/EFM32/Device/EnergyMicro/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../mcu/arm/EFM32/Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group docs
    ../../../: Revision.txt
  group Drivers
    ../../common/drivers/: AD7156.c adc.c BMM150.c bsp.c caplesense.c CapTouchDetect.c clock.c clockApp.c DelayUsingTimerInt.c dmactrl.c drv2605.c i2c_driver.c L3GD20H.c LPS22HB.c M00930.C m25pxx.c mcp9804.c Si14x.c
    ../src/: mems.c
  group DSP
    ../src/: iar_cortexM4lf_math.a
  group emlib
    ../../../mcu/arm/EFM32/emlib/src/: em_acmp.c em_adc.c em_burtc.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_msc.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group emWin
    ../../../gui/emwin/lib/: emwin_IAR_CM4F.a
    ../../../gui/emwin/portable/: GUI_X.c GUIConf.c LCDConf.c
  group FreeRTOS
    ../../../os/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../src/: FreeRTOSConfig.h
  group FreeRTOS/portable
    ../../../os/FreeRTOS/portable/CMSIS/: cmsis_os.c
    ../../../os/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c
    ../../../os/FreeRTOS/portable/LowPower/: low_power_tick_management.c
    ../../../os/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
