# IAR project Bootld.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG395F256 EnergyMicro EFM32WG395F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG395F256; BOARD_TYPE=0
  ICCARM.CCIncludePath2: ..; ..\..\CMSIS\Include; ..\..\Device\EnergyMicro\EFM32WG\Include; ..\..\emlib\inc; ..\..\usb\inc; ..\..\emwin\portable; ..\..\emwin\inc; ..\..\emwin\lib; ..\..\memlcddriver; ..\..\drivers; ..\usbhid; ..\Bootld; ..\usbhid\Boot
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootld.bin
  ILINK.IlinkOutputFile: Bootld.out
  ILINK.IlinkIcfFile: D:\tempwork\I4BOOT\proj\Bootld\Bootld.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; BOARD_TYPE=0
  OBJCOPY.OOCOutputFile: ihealthtrack_boot_ver5.bin
  ILINK.IlinkIcfFile: Bootld.icf
configuration rockband1-Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; BOARD_TYPE=2
  OBJCOPY.OOCOutputFile: rockband1_LDR.hex
  ILINK.IlinkIcfFile: Bootld.icf
configuration rockband1-Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: EFM32WG395F256; BOARD_TYPE=2; DEBUG
  ILINK.IlinkIcfFile: Bootld.icf
  group CMSIS
    ../../Device/EnergyMicro/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group Drivers
    ../../drivers/: dmactrl.c
  group emlib
    ../../emlib/src/: em_adc.c em_cmu.c em_dma.c em_emu.c em_gpio.c em_letimer.c em_system.c
    ./: em_wdog.c
  group Source
    ../usbhid/Boot/: boot.c
    ../usbhid/: GlobalData.c
    ./: loader.c
