# IAR project usbhhidkbd.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32WG395F256 EnergyMicro EFM32WG395F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32WG395F256; ewarm; BOARD_TYPE=0; DBG; VECT_TAB_RAM
  ICCARM.CCIncludePath2: ..; ..\..\..\CMSIS\Include; ..\..\..\Device\EnergyMicro\EFM32WG\Include; ..\..\..\emlib\inc; ..\..\..\usb\inc; ..\..\..\emwin\portable; ..\..\..\emwin\inc; ..\..\..\memlcddriver; ..\..\..\drivers; ..\Boot
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\..\CMSIS\Include; ..\..\..\..\..\Device\EnergyMicro\EFM32GG\Include; ..\..\..\..\..\emlib\inc; ..\..\..\..\..\usb\inc; ..\..\..\drivers; ..\..\..\bsp
  OBJCOPY.OOCOutputFile: bootld.bin
  ILINK.IlinkOutputFile: usbhhidkbd.out
  ILINK.IlinkIcfFile: EFM32-rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; BOARD_TYPE=0
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: i2-ver2-loader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: EFM32-ram.icf
configuration rockband1-Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32WG395F256; ewarm; BOARD_TYPE=2
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: i2-ver2-loader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: EFM32-ram.icf
configuration rockband1-Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; EFM32WG395F256; ewarm; BOARD_TYPE=2; VECT_TAB_RAM; SHOWLED
  group Bootloader
    ../Boot/: boot.c config.h crc.c
  group CMSIS
    ../../../Device/EnergyMicro/EFM32WG/Source/IAR/: startup_efm32wg.s
    ../../../Device/EnergyMicro/EFM32WG/Source/: system_efm32wg.c
  group drivers
    ../../../drivers/: dmactrl.c retargetio.c retargetserial.c
  group emlib
    ../../../emlib/src/: em_assert.c em_cmu.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_int.c em_letimer.c em_leuart.c em_msc.c em_system.c em_timer.c em_usart.c em_wdog.c
  group Source
    ../: BLE_LEUART_DMA.c GlobalData.c m25pxx.c main.c
